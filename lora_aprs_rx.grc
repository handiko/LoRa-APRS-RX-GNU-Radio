options:
  parameters:
    description: 'LoRa APRS receiver 432.150 MHz SF12/BW125/CR4-5: RTL-SDR -> own LoRa PHY (stock de-chirp/FFT + 3 EPBs) -> APRS decode'
    generate_options: qt_gui
    id: lora_aprs_rx
    output_language: python
    title: LoRa APRS RX 432.150 MHz (SF12 / 125 kHz / CR 4/5)
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    comment: Chips per symbol = FFT size (4096 at SF12)
    value: 2**sf
  states: {}
- name: bw
  id: variable
  parameters:
    comment: LoRa bandwidth = chip rate [Hz]
    value: 125e3
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: |-
      LoRa APRS channel centre [Hz] (your network: 432.150 MHz).
      Also used by Frame Sync to turn the measured CFO into a clock-drift correction.
    value: 432.150e6
  states: {}
- name: cr
  id: variable
  parameters:
    comment: |-
      Coding rate index 1 = 4/5 ("CR5").
      INFORMATION ONLY: the decoder reads the real CR from each frame header.
    value: '1'
  states: {}
- name: downchirp
  id: variable
  parameters:
    comment: 'Conjugate of the base up-chirp at 1 sample/chip: the de-chirping reference'
    value: list(np.exp(-2j*np.pi*(np.arange(N)**2/(2.0*N) - np.arange(N)/2.0)))
  states: {}
- name: if_offset
  id: variable
  parameters:
    comment: |-
      RTL-SDR is tuned this far BELOW the channel so LoRa sits away from the DC spike / IQ image;
      the Xlating filter brings it back to 0 Hz.
    value: 200e3
  states: {}
- name: ldro
  id: variable
  parameters:
    comment: 'Low Data Rate Optimisation: ON for SF12/125k (32.8 ms symbols). SX127x/SX126x firmware sets it automatically.'
    value: 1 if (2**sf)/bw > 16e-3 else 0
  states: {}
- name: os_factor
  id: variable
  parameters:
    comment: RTL-SDR samples per chip
    value: '8'
  states: {}
- name: preamble_len
  id: variable
  parameters:
    comment: Programmed preamble length of the trackers (8 is the LoRa APRS default)
    value: '8'
  states: {}
- name: rec_file
  id: variable
  parameters:
    comment: 'PLAYBACK ONLY: complex64 IQ recorded at samp_rate, tuned to center_freq - if_offset'
    value: '"lora_aprs_432150_1Msps.cf32"'
  states: {}
- name: rtl_gain
  id: variable_qtgui_range
  parameters:
    comment: RF gain. Start ~30 dB; back off if a nearby tracker overloads the dongle.
    gui_hint: 0,0,1,2
    label: '"RTL-SDR gain [dB]"'
    start: '0'
    step: '0.1'
    stop: '49.6'
    value: '35'
  states: {}
- name: rtl_ppm
  id: variable
  parameters:
    comment: 'RTL-SDR crystal correction [ppm]. v3/v4 (TCXO): 0..1. Old dongles: measure it.'
    value: '35'
  states: {}
- name: rx_os
  id: variable
  parameters:
    comment: 'Samples per chip into Frame Sync (500 kS/s): 4 sampling phases for fractional timing'
    value: '4'
  states: {}
- name: rx_rate
  id: variable
  parameters:
    comment: Sample rate into Frame Sync
    value: bw*rx_os
  states: {}
- name: rx_taps
  id: variable
  parameters:
    comment: 'Channel filter: pass the +-62.5 kHz LoRa channel, stop beyond 90 kHz'
    value: firdes.low_pass(1.0, samp_rate, 80e3, 20e3)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 'RTL-SDR sample rate: 1.000 MS/s (must be an integer multiple of bw)'
    value: bw*os_factor
  states: {}
- name: sf
  id: variable
  parameters:
    comment: 'Spreading factor (LoRa APRS standard: SF12)'
    value: '12'
  states: {}
- name: sync_word
  id: variable
  parameters:
    comment: 'LoRa APRS uses the SX127x private sync word 0x12 (on air: bins 8 and 16)'
    value: '0x12'
  states: {}
- name: t_sym
  id: variable
  parameters:
    comment: 'Symbol time [s]: 32.77 ms at SF12/125k'
    value: (2**sf)/bw
  states: {}
- name: aprs
  id: epy_block
  parameters:
    _source_code: |
      """
      LoRa APRS Parser -- message-only Embedded Python Block (EPB #5).

      Input  'pdu' : PDU (meta, u8vector) from the LoRa PHY Decoder's 'payload' port.
      Output 'aprs': PDU (meta, u8vector) holding just the TNC2 text line
                     ("SRC>DST,PATH:info") of every good packet, ready for a stock
                     Socket PDU / Message Debug / File-logging chain.

      LoRa APRS framing (lora-aprs / CA2RXU / OE5BPA firmware family):
          3 header bytes  '<' 0xFF 0x01   then plain TNC2 text, no AX.25, no FCS.
          (The LoRa CRC-16 is the only integrity check.)

      Decodes the APRS formats LoRa trackers and iGates actually send:
          ! = / @      position, uncompressed or base-91 compressed (+course/speed/alt)
          ` '          Mic-E (lat/lon from the destination field, speed/course, alt)
          ;  )         objects and items
          :            messages (incl. ack/rej, message number)
          >            status
          T#           telemetry (printed raw)
          }            third-party (inner packet parsed recursively)
      Anything else is printed as raw info text.
      """
      import time
      import urllib.parse
      import pmt
      from gnuradio import gr

      SYMBOLS = {
          '/>': 'car', '/<': 'motorcycle', '/[': 'jogger', '/b': 'bicycle', '/k': 'truck',
          '/v': 'van', '/u': 'truck (18-wheeler)', '/j': 'jeep', '/R': 'RV', '/Y': 'yacht',
          '/s': 'ship', '/f': 'fire truck', '/a': 'ambulance', '/O': 'balloon', '/^': 'aircraft',
          '/X': 'helicopter', '/-': 'house', '/#': 'digipeater', '/&': 'gateway', '/_': 'weather station',
          '/r': 'repeater', '/y': 'house + yagi', '/`': 'dish antenna', '/n': 'node',
          '\\&': 'gateway (overlay)', 'L&': 'LoRa iGate', 'L#': 'LoRa digipeater',
          'I&': 'iGate', '\\#': 'digipeater (overlay)', '/l': 'laptop', '/$': 'phone',
      }

      MICE_MSG = {7: 'Off Duty', 6: 'En Route', 5: 'In Service', 4: 'Returning',
                  3: 'Committed', 2: 'Special', 1: 'Priority', 0: 'EMERGENCY'}


      def b91(s):
          v = 0
          for c in s:
              v = v * 91 + (ord(c) - 33)
          return v


      class blk(gr.basic_block):
          """LoRa APRS Parser: strips the '<\\xff\\x01' header and decodes TNC2 APRS"""

          def __init__(self, show_bad_crc=False, log_path=''):
              gr.basic_block.__init__(self, name='LoRa APRS Parser', in_sig=None, out_sig=None)
              self.show_bad_crc = bool(show_bad_crc)
              self.log_path = str(log_path)
              self.message_port_register_in(pmt.intern('pdu'))
              self.set_msg_handler(pmt.intern('pdu'), self.handle)
              self.message_port_register_out(pmt.intern('aprs'))
              self.count = 0

          # ================================================================ entry
          def handle(self, msg):
              try:
                  meta = pmt.to_python(pmt.car(msg)) or {}
                  data = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              except Exception as e:                      # not a PDU
                  print('[APRS] bad PDU: %s' % e, flush=True)
                  return
              crc = meta.get('crc', 'none')
              if crc == 'FAIL' and not self.show_bad_crc:
                  print('[APRS] frame dropped: LoRa CRC failed (%d bytes)' % len(data), flush=True)
                  return

              if data[:3] == b'<\xff\x01':
                  text, framing = data[3:], 'LoRa-APRS'
              else:
                  text, framing = data, 'no <FF01 header'
              line = text.decode('utf-8', errors='replace').rstrip('\r\n\x00')

              self.count += 1
              stamp = time.strftime('%H:%M:%S')
              print('\n' + '=' * 72, flush=True)
              print('[APRS #%d %s] %s   (LoRa CRC %s, SNR %.1f dB, CFO %+.0f Hz, %s)'
                    % (self.count, stamp, line, crc, meta.get('snr_db', 0.0),
                       meta.get('cfo_hz', 0.0), framing), flush=True)
              for row in self.decode_tnc2(line):
                  print('    ' + row, flush=True)
              print('=' * 72, flush=True)

              raw = line.encode('utf-8', errors='replace')
              self.message_port_pub(pmt.intern('aprs'),
                                    pmt.cons(pmt.car(msg), pmt.init_u8vector(len(raw), list(raw))))
              if self.log_path:
                  try:
                      with open(self.log_path, 'a', encoding='utf-8') as f:
                          f.write('%s\t%s\t%s\n' % (time.strftime('%Y-%m-%d %H:%M:%S'), crc, line))
                  except OSError as e:
                      print('[APRS] log write failed: %s' % e, flush=True)

          # ================================================================ TNC2
          def decode_tnc2(self, line, depth=0):
              rows = []
              if '>' not in line or ':' not in line:
                  return ['(not a TNC2 APRS line)']
              head, info = line.split(':', 1)
              src, rest = head.split('>', 1)
              parts = rest.split(',')
              dst, path = parts[0], parts[1:]
              rows.append('From %s  to %s%s' % (src, dst, ('  via ' + ','.join(path)) if path else ''))
              if not info:
                  return rows + ['(empty info field)']
              try:
                  rows += self.decode_info(info, dst, depth)
              except Exception as e:                       # malformed packet: show what we can
                  rows.append('Info (unparsed, %s): %s' % (e.__class__.__name__, info))
              if depth == 0:
                  call = urllib.parse.quote('a/' + src, safe='')
                  rows.append('Map:  https://aprs.fi/#!call=%s' % call)
              return rows

          def decode_info(self, info, dst, depth):
              t = info[0]
              if t in '!=':
                  return self.position(info[1:], 'Position%s' % (' (messaging)' if t == '=' else ''))
              if t in '/@':
                  return ['Time %s' % self.timestamp(info[1:8])] + \
                      self.position(info[8:], 'Position%s' % (' (messaging)' if t == '@' else ''))
              if t in '`\'\x1c\x1d':
                  return self.mic_e(info, dst)
              if t == ';':
                  name, live = info[1:10].rstrip(), info[10]
                  rows = ['Object "%s" (%s)  time %s' % (name, 'live' if live == '*' else 'killed',
                                                        self.timestamp(info[11:18]))]
                  return rows + self.position(info[18:], 'Object position')
              if t == ')':
                  k = min([i for i in (info.find('!', 1), info.find('_', 1)) if i > 0] or [len(info)])
                  return ['Item "%s"' % info[1:k]] + self.position(info[k + 1:], 'Item position')
              if t == ':':
                  to, body = info[1:10].strip(), info[11:]
                  num = ''
                  if '{' in body:
                      body, num = body.rsplit('{', 1)
                  if body.startswith('ack') or body.startswith('rej'):
                      return ['%s for message %s to %s' % (body[:3].upper(), body[3:], to)]
                  return ['Message to %s: "%s"%s' % (to, body, ('  [msg no %s]' % num) if num else '')]
              if t == '>':
                  return ['Status: %s' % info[1:]]
              if t == 'T':
                  return ['Telemetry: %s' % info[1:]]
              if t == '}' and depth < 3:
                  return ['Third-party packet:'] + ['  ' + r for r in self.decode_tnc2(info[1:], depth + 1)]
              return ['Info: %s' % info]

          # ================================================================ helpers
          @staticmethod
          def timestamp(s):
              if len(s) < 7:
                  return s
              if s[6] in 'z/':
                  return 'day %s %s:%s %s' % (s[0:2], s[2:4], s[4:6], 'UTC' if s[6] == 'z' else 'local')
              if s[6] == 'h':
                  return '%s:%s:%s UTC' % (s[0:2], s[2:4], s[4:6])
              return s

          @staticmethod
          def sym(table, code):
              key = table + code
              name = SYMBOLS.get(key) or SYMBOLS.get('\\' + code if table not in '/\\' else key, '')
              return 'symbol %s%s%s' % (table, code, ('  (%s)' % name) if name else '')

          @staticmethod
          def latlon_str(lat, lon):
              return '%+.5f, %+.5f   (%s %s)' % (
                  lat, lon,
                  "%d°%06.3f'%s" % (int(abs(lat)), (abs(lat) % 1) * 60, 'N' if lat >= 0 else 'S'),
                  "%d°%06.3f'%s" % (int(abs(lon)), (abs(lon) % 1) * 60, 'E' if lon >= 0 else 'W'))

          def position(self, s, label):
              if not s:
                  return ['%s: (missing)' % label]
              if s[0].isdigit() or s[0] == ' ':
                  return self.pos_uncompressed(s, label)
              return self.pos_compressed(s, label)

          def pos_uncompressed(self, s, label):
              lat_s, table, lon_s, code, comment = s[0:8], s[8], s[9:18], s[18], s[19:]
              lat = (int(lat_s[0:2]) + float(lat_s[2:7].replace(' ', '0')) / 60.0) * \
                  (1 if lat_s[7] in 'Nn' else -1)
              lon = (int(lon_s[0:3]) + float(lon_s[3:8].replace(' ', '0')) / 60.0) * \
                  (1 if lon_s[8] in 'Ee' else -1)
              rows = ['%s: %s' % (label, self.latlon_str(lat, lon)),
                      '%s  (uncompressed)' % self.sym(table, code)]
              motion = []
              if len(comment) >= 7 and comment[3] == '/' and comment[:3].isdigit() and comment[4:7].isdigit():
                  motion.append('course %d°  speed %d km/h' % (int(comment[:3]),
                                                              round(int(comment[4:7]) * 1.852)))
                  comment = comment[7:]
              i = comment.find('/A=')
              if i >= 0 and comment[i + 3:i + 9].lstrip('-').isdigit():
                  motion.append('alt %d m' % round(int(comment[i + 3:i + 9]) * 0.3048))
                  comment = comment[:i] + comment[i + 9:]
              if motion:
                  rows.append('  '.join(motion))
              if comment.strip():
                  rows.append('Comment: %s' % comment.strip())
              return rows

          def pos_compressed(self, s, label):
              table, lat4, lon4, code, cs, ctype, comment = s[0], s[1:5], s[5:9], s[9], s[10:12], s[12], s[13:]
              lat = 90.0 - b91(lat4) / 380926.0
              lon = -180.0 + b91(lon4) / 190463.0
              rows = ['%s: %s' % (label, self.latlon_str(lat, lon)),
                      '%s  (compressed)' % self.sym(table, code)]
              motion = []
              if cs[0] != ' ':
                  c, sp = ord(cs[0]) - 33, ord(cs[1]) - 33
                  T = ord(ctype) - 33
                  if (T & 0x18) == 0x10:                                  # GGA source -> altitude
                      motion.append('alt %d m' % round((1.002 ** (c * 91 + sp)) * 0.3048))
                  elif 0 <= c <= 89:
                      motion.append('course %d°  speed %d km/h'
                                    % (c * 4, round((1.08 ** sp - 1) * 1.852)))
                  elif c == 90:
                      motion.append('radio range %.0f km' % (2 * 1.08 ** sp * 1.609))
              i = comment.find('/A=')
              if i >= 0 and comment[i + 3:i + 9].lstrip('-').isdigit():
                  motion.append('alt %d m' % round(int(comment[i + 3:i + 9]) * 0.3048))
                  comment = comment[:i] + comment[i + 9:]
              if motion:
                  rows.append('  '.join(motion))
              if comment.strip():
                  rows.append('Comment: %s' % comment.strip())
              return rows

          def mic_e(self, info, dst):
              d = dst.split('-')[0]
              if len(d) < 6 or len(info) < 9:
                  return ['Mic-E (truncated): %s' % info]
              digits, bits, custom = [], [], False
              for ch in d[:6]:
                  if ch.isdigit():
                      digits.append(int(ch)); bits.append(0)
                  elif 'A' <= ch <= 'J':
                      digits.append(ord(ch) - 65); bits.append(1); custom = True
                  elif 'P' <= ch <= 'Y':
                      digits.append(ord(ch) - 80); bits.append(1)
                  elif ch in 'KLZ':
                      digits.append(0); bits.append(0 if ch == 'L' else 1); custom |= ch == 'K'
                  else:
                      return ['Mic-E (bad destination %s): %s' % (dst, info)]
              lat = digits[0] * 10 + digits[1] + (digits[2] * 10 + digits[3] + (digits[4] * 10 + digits[5]) / 100.0) / 60.0
              north = d[3] >= 'P'
              lon_off = 100 if d[4] >= 'P' else 0
              west = d[5] >= 'P'
              lat = lat if north else -lat

              deg = ord(info[1]) - 28 + lon_off
              if 180 <= deg <= 189:
                  deg -= 80
              elif 190 <= deg <= 199:
                  deg -= 190
              mins = ord(info[2]) - 28
              if mins >= 60:
                  mins -= 60
              hund = ord(info[3]) - 28
              lon = deg + (mins + hund / 100.0) / 60.0
              lon = -lon if west else lon

              sp, dc, se = ord(info[4]) - 28, ord(info[5]) - 28, ord(info[6]) - 28
              speed = sp * 10 + dc // 10
              if speed >= 800:
                  speed -= 800
              course = (dc % 10) * 100 + se
              if course >= 400:
                  course -= 400
              code, table, comment = info[7], info[8], info[9:]

              msg_id = bits[0] * 4 + bits[1] * 2 + bits[2]
              status = ('Custom-%d' % msg_id) if custom else MICE_MSG.get(msg_id, '?')
              rows = ['Mic-E position: %s' % self.latlon_str(lat, lon),
                      '%s   status: %s' % (self.sym(table, code), status)]
              motion = ['course %d°  speed %d km/h' % (course, round(speed * 1.852))]
              # optional altitude: 3 base-91 chars followed by '}' (metres + 10000)
              for k in (0, 1):
                  if len(comment) >= k + 4 and comment[k + 3] == '}':
                      motion.append('alt %d m' % (b91(comment[k:k + 3]) - 10000))
                      comment = comment[:k] + comment[k + 4:]
                      break
              rows.append('  '.join(motion))
              comment = comment.lstrip('>]`\'').rstrip()
              if comment:
                  rows.append('Comment: %s' % comment)
              return rows
    comment: |-
      EPB #3: strip "<\xff\x01", parse TNC2 APRS,
      print position / Mic-E / message / status.
      log_path="lora_aprs.log" to keep a log.
    log_path: '""'
    show_bad_crc: 'False'
  states: {}
- name: argmax
  id: blocks_argmax_xx
  parameters:
    comment: Strongest bin = symbol value
    num_inputs: '1'
    type: float
    vlen: N
  states: {}
- name: argmax_null
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: dechirp
  id: blocks_multiply_const_vxx
  parameters:
    comment: DE-CHIRP each aligned symbol
    const: downchirp
    type: complex
    vlen: N
  states: {}
- name: fft_sync
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(N)
  states: {}
- name: file_source
  id: blocks_file_source
  parameters:
    comment: 'PLAYBACK: enable this + Throttle, disable the RTL-SDR source.'
    file: rec_file
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: lora_dec
  id: epy_block
  parameters:
    _source_code: |
      """
      LoRa PHY Decoder -- inverse of the LoRa PHY chain (same design as
      lora_trx_sim.grc, EPB #4).

      Input : int16 symbol values (FFT argmax bins) from the stock Argmax block.
              A 'frame_start' tag (set by the Frame Sync block, carried through the
              stock Multiply/FFT/Mag^2/Argmax blocks) marks the first symbol of a frame.

      Per symbol:   bin -> (bin - 1) mod N -> Gray code -> (>> 2 for reduced rate)
      Per block:    de-interleave (undo the diagonal) -> Hamming decode -> nibbles
      Header block: 8 symbols, SF-2 bits, CR 4/8 -> length, CR, CRC flag, checksum.
                    Result is sent back to Frame Sync ('frame_info') so it knows how
                    many more symbols to cut out of the stream.
      Payload:      nibbles (low first) -> bytes -> de-whiten -> CRC-16 check.

      Message out 'frame_info': {'n_sym': n} or {'abort': True}
      Message out 'payload'   : PDU (meta dict, u8vector) for every decoded frame.
      """
      import numpy as np
      import pmt
      from gnuradio import gr


      def lora_n_payload_symbols(sf, cr, payload_len, has_crc, ldro):
          num = 8 * payload_len - 4 * sf + 28 + 16 * int(bool(has_crc))
          den = 4 * (sf - 2 * int(bool(ldro)))
          return 8 + max(-(-num // den) * (cr + 4), 0)


      def hamming_enc(nib, cr_app):                       # identical to the TX encoder
          d = [(nib >> 3) & 1, (nib >> 2) & 1, (nib >> 1) & 1, nib & 1]
          if cr_app == 1:
              p4 = d[0] ^ d[1] ^ d[2] ^ d[3]
              return (d[3] << 4) | (d[2] << 3) | (d[1] << 2) | (d[0] << 1) | p4
          p0 = d[3] ^ d[2] ^ d[1]
          p1 = d[2] ^ d[1] ^ d[0]
          p2 = d[3] ^ d[2] ^ d[0]
          p3 = d[3] ^ d[1] ^ d[0]
          cw = ((d[3] << 7) | (d[2] << 6) | (d[1] << 5) | (d[0] << 4) |
                (p0 << 3) | (p1 << 2) | (p2 << 1) | p3)
          return cw >> (4 - cr_app)


      class blk(gr.sync_block):
          """LoRa PHY Decoder: Gray, de-interleave, Hamming, header, de-whiten, CRC"""

          def __init__(self, sf=12, ldro=1, verbose=True):
              gr.sync_block.__init__(self, name='LoRa PHY Decoder',
                                     in_sig=[np.int16], out_sig=None)
              self.sf = int(sf)
              self.N = 1 << self.sf
              self.ldro = bool(ldro)
              self.verbose = bool(verbose)
              seq, reg = [], 0xFF
              for _ in range(255):
                  seq.append(reg)
                  fb = ((reg >> 7) ^ (reg >> 5) ^ (reg >> 4) ^ (reg >> 3)) & 1
                  reg = ((reg << 1) & 0xFF) | fb
              self.whitening_seq = np.array(seq, dtype=np.uint8)
              # code books for nearest-codeword decoding
              self.book = {c: [hamming_enc(n, c) for n in range(16)] for c in (1, 2, 3, 4)}
              self.message_port_register_out(pmt.intern('frame_info'))
              self.message_port_register_out(pmt.intern('payload'))
              self.syms = None
              self.hdr = None
              self.meta = {}
              self.stats = {'frames': 0, 'crc_ok': 0, 'crc_bad': 0, 'hdr_bad': 0}

          # ---------------- symbol -> bits ----------------
          def sym_to_word(self, s, reduced):
              v = (int(s) - 1) % self.N          # undo the +1 shift
              v ^= v >> 1                        # Gray code (undoes TX inverse-Gray)
              return v >> 2 if reduced else v    # reduced rate: drop the 2 LSBs

          @staticmethod
          def deinterleave(words, sf_app, cw_len):
              cws = []
              for k in range(sf_app):
                  c = 0
                  for i in range(cw_len):
                      j = (i - k - 1) % sf_app
                      c = (c << 1) | ((words[i] >> (sf_app - 1 - j)) & 1)
                  cws.append(c)
              return cws

          def hamming_dec(self, cw, cr_app):
              if cr_app >= 3:                    # 4/7, 4/8: correct 1 bit (nearest codeword)
                  dists = [bin(cw ^ c).count('1') for c in self.book[cr_app]]
                  return int(np.argmin(dists))
              top = cw >> cr_app                 # 4/5, 4/6: detection only, just read data bits
              return ((top >> 3) & 1) | (((top >> 2) & 1) << 1) | (((top >> 1) & 1) << 2) | ((top & 1) << 3)

          def block_nibbles(self, syms, sf_app, cr_app):
              reduced = sf_app != self.sf
              words = [self.sym_to_word(s, reduced) for s in syms]
              return [self.hamming_dec(c, cr_app)
                      for c in self.deinterleave(words, sf_app, cr_app + 4)]

          @staticmethod
          def crc16(data):
              crc = 0
              for byte in data:
                  byte = int(byte)
                  for _ in range(8):
                      if ((crc & 0x8000) >> 8) ^ (byte & 0x80):
                          crc = ((crc << 1) ^ 0x1021) & 0xFFFF
                      else:
                          crc = (crc << 1) & 0xFFFF
                      byte = (byte << 1) & 0xFF
              return crc

          # ---------------- frame logic ----------------
          def parse_header(self):
              nib = self.block_nibbles(self.syms[:8], self.sf - 2, 4)
              h0, h1, h2, c4n, c30 = nib[:5]
              b = lambda v, k: (v >> k) & 1
              c4 = b(h0, 3) ^ b(h0, 2) ^ b(h0, 1) ^ b(h0, 0)
              c3 = b(h0, 3) ^ b(h1, 3) ^ b(h1, 2) ^ b(h1, 1) ^ b(h2, 0)
              c2 = b(h0, 2) ^ b(h1, 3) ^ b(h1, 0) ^ b(h2, 3) ^ b(h2, 1)
              c1 = b(h0, 1) ^ b(h1, 2) ^ b(h1, 0) ^ b(h2, 2) ^ b(h2, 1) ^ b(h2, 0)
              c0 = b(h0, 0) ^ b(h1, 1) ^ b(h2, 3) ^ b(h2, 2) ^ b(h2, 1) ^ b(h2, 0)
              L, cr, crc = (h0 << 4) | h1, h2 >> 1, h2 & 1
              if (c4n & 1) != c4 or c30 != ((c3 << 3) | (c2 << 2) | (c1 << 1) | c0) \
                      or L == 0 or not 1 <= cr <= 4:
                  return None
              return {'len': L, 'cr': cr, 'crc': crc, 'nibs': nib[5:],
                      'n_sym': lora_n_payload_symbols(self.sf, cr, L, crc, self.ldro)}

          def finish_frame(self):
              h = self.hdr
              nibs = list(h['nibs'])
              sf_app = self.sf - 2 if self.ldro else self.sf
              cw_len = 4 + h['cr']
              rest = self.syms[8:h['n_sym']]
              for i in range(0, len(rest), cw_len):
                  nibs += self.block_nibbles(rest[i:i + cw_len], sf_app, h['cr'])
              L = h['len']
              wh = np.array([nibs[2 * i] | (nibs[2 * i + 1] << 4) for i in range(L)], dtype=np.uint8)
              payload = wh ^ self.whitening_seq[:L]
              crc_ok = None
              if h['crc']:
                  cn = nibs[2 * L:2 * L + 4]
                  rx_crc = cn[0] | (cn[1] << 4) | (cn[2] << 8) | (cn[3] << 12)
                  calc = self.crc16(payload[:-2]) ^ int(payload[-1]) ^ (int(payload[-2]) << 8)
                  crc_ok = rx_crc == calc
              self.stats['frames'] += 1
              self.stats['crc_ok' if crc_ok in (True, None) else 'crc_bad'] += 1
              meta = dict(self.meta)
              meta.update({'len': L, 'cr': '4/%d' % (4 + h['cr']),
                           'crc': {True: 'OK', False: 'FAIL', None: 'none'}[crc_ok]})
              self.message_port_pub(pmt.intern('payload'),
                                    pmt.cons(pmt.to_pmt(meta), pmt.init_u8vector(L, payload.tolist())))
              if self.verbose:
                  print('[LoRa RX] frame %d  len %d  CR %s  CRC %s  CFO %+.0f Hz  SNR %.1f dB'
                        % (self.stats['frames'], L, meta['cr'], meta['crc'],
                           meta.get('cfo_hz', 0.0), meta.get('snr_db', 0.0)), flush=True)

          def work(self, input_items, output_items):
              inp = input_items[0]
              base = self.nitems_read(0)
              starts = {t.offset - base: t for t in
                        self.get_tags_in_window(0, 0, len(inp), pmt.intern('frame_start'))}
              for i in range(len(inp)):
                  if i in starts:
                      self.syms, self.hdr = [], None
                      try:
                          self.meta = pmt.to_python(starts[i].value)
                      except Exception:
                          self.meta = {}
                  if self.syms is None:
                      continue
                  self.syms.append(int(inp[i]))
                  if self.hdr is None and len(self.syms) == 8:
                      self.hdr = self.parse_header()
                      if self.hdr is None:
                          self.stats['hdr_bad'] += 1
                          if self.verbose:
                              print('[LoRa RX] header checksum failed', flush=True)
                          self.message_port_pub(pmt.intern('frame_info'),
                                                pmt.to_pmt({'abort': True}))
                          self.syms = None
                          continue
                      self.message_port_pub(pmt.intern('frame_info'),
                                            pmt.to_pmt({'n_sym': self.hdr['n_sym']}))
                  if self.hdr is not None and len(self.syms) == self.hdr['n_sym']:
                      self.finish_frame()
                      self.syms, self.hdr = None, None
              return len(inp)
    comment: |-
      EPB #2: Gray, de-interleave, Hamming, header,
      de-whiten, CRC-16 -> payload PDU
    ldro: ldro
    sf: sf
    verbose: 'True'
  states: {}
- name: lora_sync
  id: epy_block
  parameters:
    _source_code: |
      """
      LoRa Frame Synchroniser -- the one part of a LoRa receiver GNU Radio has no
      stock block for: deciding WHERE each symbol starts and HOW FAR off-tune we are.
      (Same design as lora_trx_sim.grc, EPB #3.)

      Input : complex baseband at os samples per chip (samp_rate = os * bw)
      Output: a complex STREAM, emitted in blocks of N = 2^SF samples, ONE BLOCK PER
              PAYLOAD SYMBOL (a stock Stream to Vector N block downstream turns each
              block into one vector). Each block is already
              - aligned to the symbol boundary (integer + fractional timing),
              - decimated to 1 sample per chip at the best sampling phase,
              - frequency-corrected (fractional + integer CFO),
              - drift-corrected (sampling-clock offset derived from the CFO).
              The de-chirp, FFT and argmax that turn these vectors into symbol
              values are done DOWNSTREAM by stock blocks (Multiply Const, FFT,
              Complex to Mag^2, Argmax).
              The first sample of every frame carries a 'frame_start' stream tag.
              (Why a stream and not a vector port: GRC sizes Embedded-Python ports
              from the constructor's DEFAULT arguments, so a vector port would stay
              at the default SF's length and turn the connection red for other SFs.)

      Message in 'frame_info': the header decoder answers {'n_sym': n} (total symbols
              incl. the 8 header symbols) or {'abort': True} after the first 8.

      State machine:
        DETECT  free-running de-chirp (window grid not aligned to anything).
                A preamble = several consecutive windows whose FFT peak sits in
                the SAME bin.  That bin = timing offset + CFO (mixed together).
        ALIGN   (instant) fractional CFO from the peak's phase rotation between
                windows; fractional timing by trying all os sampling phases;
                shift the window grid by the peak bin -> up-chirps now land in bin 0.
        SFD     step symbol by symbol, de-chirping each window with BOTH chirp
                directions.  Sync-word chirps show up as bins (8*hi, 8*lo).
                The first window where the DOWN-chirp de-chirp wins is the SFD;
                its bin = 2 x integer CFO  -> CFO and timing finally separated.
        OUTPUT  emit 8 header symbols, wait for the header decoder's length,
                emit the rest, go back to DETECT.
      """
      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          """LoRa Frame Sync: preamble detect, CFO/STO estimation, SFD, symbol windows"""

          def __init__(self, sf=12, bw=125e3, samp_rate=500e3, sync_word=0x12,
                       preamble_len=8, center_freq=432.15e6, sro_comp=True, track=True,
                       verbose=True):
              self.sf = int(sf)
              self.N = 1 << self.sf
              gr.basic_block.__init__(self, name='LoRa Frame Sync',
                                      in_sig=[np.complex64],
                                      out_sig=[np.complex64])
              self.set_output_multiple(self.N)            # always emit whole symbols
              self.bw = float(bw)
              self.fs = float(samp_rate)
              os_f = self.fs / self.bw
              assert abs(os_f - round(os_f)) < 1e-9 and os_f >= 1, \
                  'samp_rate must be an integer multiple of bw'
              self.os = int(round(os_f))
              self.L = self.N * self.os                    # input samples per symbol
              self.preamble_len = int(preamble_len)
              sw = int(sync_word) & 0xFF
              self.sync_syms = ((sw >> 4) << 3, (sw & 0x0F) << 3)
              self.fc = float(center_freq)
              self.sro_comp = bool(sro_comp) and self.fc > 0
              self.verbose = bool(verbose)
              self.track = bool(track)
              # Frequency tracking through the payload (2nd-order loop, units = FFT bins).
              # Real trackers drift tens of Hz during a 3 s SF12 frame (PA warms the crystal);
              # 1 bin is only 30.5 Hz at SF12/125k, so a frequency frozen at the preamble
              # pushes late symbols into the neighbouring bin.
              self.trk_g1 = 0.3                             # phase-detector -> frequency gain
              self.trk_g2 = 0.02                            # -> frequency-rate gain (follows ramps)
              self.trk_gate = 2.0 * np.log(self.N)          # only learn from clearly-decided symbols
              self.kk = np.arange(self.N)

              n = np.arange(self.N)
              self.up = np.exp(2j * np.pi * (n * n / (2.0 * self.N) - n / 2.0))  # base up-chirp, 1 sample/chip
              self.down = np.conj(self.up)

              self.DET = 3                                  # consecutive matching windows = preamble
              self.thr = 1.5 * np.log(self.N)               # min peak-to-mean ratio of a window
              # noise alone passes thr in ~N*exp(-thr) = 1.5 % of windows (SF12); three in a
              # row within +-1 bin of each other: ~1e-12 per window -> no false alarms.

              self.buf = np.zeros(0, dtype=np.complex64)
              self.buf_start = 0                            # absolute index of buf[0]
              self.pos = 0.0                                # absolute index of next window start
              self.reset()

              self.message_port_register_in(pmt.intern('frame_info'))
              self.set_msg_handler(pmt.intern('frame_info'), self.handle_frame_info)
              self.set_tag_propagation_policy(gr.TPP_DONT)
              self.frames = 0

          # ------------------------------------------------------------ helpers
          def reset(self):
              self.state = 'DETECT'
              self.hist = []          # DETECT: (start, Y, k) of recent windows
              self.cfo_norm = 0.0     # applied CFO correction, cycles per input sample
              self.up_bins = []       # SFD search: bins of up-chirp windows seen
              self.L_eff = float(self.L)
              self.trk_f = 0.0        # tracked extra frequency correction [bins]
              self.trk_r = 0.0        # tracked drift rate [bins/symbol]
              self.trk_hist = []
              self.n_out = 0
              self.n_total = None
              self.info = {}

          def handle_frame_info(self, msg):
              d = pmt.to_python(msg)
              if self.state != 'OUTPUT':
                  return
              if d.get('abort', False):
                  if self.verbose:
                      print('[LoRa sync] header rejected -> back to DETECT', flush=True)
                  self.reset()
              else:
                  self.n_total = int(d['n_sym'])

          def have(self, start, length):
              s = int(round(start))
              return s >= self.buf_start and s + length <= self.buf_start + len(self.buf)

          def window(self, start, phase=0):
              """N samples, one per chip, starting at absolute sample start+phase, CFO-corrected."""
              idx = int(round(start)) + phase + np.arange(self.N) * self.os
              x = self.buf[idx - self.buf_start].astype(np.complex128)
              if self.cfo_norm != 0.0:
                  x = x * np.exp(-2j * np.pi * ((self.cfo_norm * idx) % 1.0))
              return x

          def spec_up(self, x):     # de-chirp UP-chirps (multiply by down-chirp), FFT
              return np.fft.fft(x * self.down)

          def spec_down(self, x):   # de-chirp DOWN-chirps (multiply by up-chirp), FFT
              return np.fft.fft(x * self.up)

          def signed(self, k):
              return k - self.N if k >= self.N // 2 else k

          # ------------------------------------------------------------ states
          def step_detect(self):
              if not self.have(self.pos, self.L + self.os):
                  return False
              Y = self.spec_up(self.window(self.pos))
              P = np.abs(Y) ** 2
              k = int(np.argmax(P))
              ratio = P[k] / (np.mean(P) + 1e-30)
              if ratio > self.thr:
                  self.hist.append((self.pos, Y, k))
                  self.hist = self.hist[-self.DET:]
              else:
                  self.hist = []
              if len(self.hist) == self.DET:
                  ks = [h[2] for h in self.hist]
                  ok = all(abs(self.signed((ks[i + 1] - ks[i]) % self.N)) <= 1
                           for i in range(self.DET - 1))
                  if ok:
                      self.align()
                      return True
                  self.hist = self.hist[1:]
              self.pos += self.L
              return True

          def align(self):
              # (1) fractional CFO: the preamble is periodic, so window i+1 is window i
              #     rotated by 2*pi*CFO[bins].  Only the fraction of a bin is visible.
              k0 = self.hist[-1][2]
              z = sum(self.hist[i + 1][1][k0] * np.conj(self.hist[i][1][k0])
                      for i in range(self.DET - 1))
              cfo_frac = np.angle(z) / (2 * np.pi)                     # bins, (-0.5, 0.5]
              self.cfo_norm = cfo_frac / self.L                         # cycles / input sample

              # (2) fractional timing: try every sampling phase, keep the sharpest peak
              w = self.hist[-1][0]
              best = (-1.0, 0, 0)
              for d in range(self.os):
                  P = np.abs(self.spec_up(self.window(w, d))) ** 2 + \
                      np.abs(self.spec_up(self.window(w - self.L, d))) ** 2
                  k = int(np.argmax(P))
                  if P[k] > best[0]:
                      best = (P[k], d, k)
              Pk, d, k = best
              P = np.abs(self.spec_up(self.window(w, d))) ** 2
              noise = (np.sum(P) - P[k]) / (self.N - 1)
              snr = 10 * np.log10(max(P[k] - noise, 1e-12) / (self.N * noise + 1e-30))

              # (3) integer alignment: peak bin k = timing offset + integer CFO (chips).
              #     Shift the grid by k chips so preamble up-chirps de-chirp to bin 0.
              self.pos = w + d - self.signed(k) * self.os
              self.info = {'cfo_frac_bins': float(cfo_frac), 'preamble_bin': int(k),
                           'phase': int(d), 'snr_db': float(snr)}
              self.state = 'SFD'
              self.up_bins = []
              self.align_pos = self.pos                 # reference instant for drift correction

          def step_sfd(self):
              if not self.have(self.pos, self.L + self.os):
                  return False
              x = self.window(self.pos)
              Pu = np.abs(self.spec_up(x)) ** 2
              Pd = np.abs(self.spec_down(x)) ** 2
              ku, kd = int(np.argmax(Pu)), int(np.argmax(Pd))
              if Pd[kd] <= Pu[ku]:                       # still an up-chirp (preamble / sync)
                  self.up_bins.append(ku)
                  if len(self.up_bins) > self.preamble_len + 4:
                      self.reset()                       # never found an SFD: false alarm
                  self.pos += self.L
                  return True

              # ---- SFD found.
              # Since ALIGN the grid has stepped by the nominal L, so clock drift has moved
              # it by d chips (0.25 chip/symbol at SF12 per 60 ppm).  Up-chirps read s + d,
              # the SFD down-chirp reads 2*CFO - d.  d is measured from the sync word.
              sync = tuple(self.up_bins[-2:])
              err = [self.signed((sync[i] - self.sync_syms[i]) % self.N) for i in range(len(sync))]
              d = float(np.mean(err)) if len(err) == 2 else 0.0
              sw_ok = len(sync) == 2 and abs(d) <= 3.5 and all(abs(e - d) <= 1 for e in err)
              f_int = int(np.round((self.signed(kd) + d) / 2.0))
              if not sw_ok:
                  if self.verbose:
                      print('[LoRa sync] SFD found but sync word bins %s != %s -> ignored'
                            % (sync, self.sync_syms), flush=True)
                  self.pos += self.L
                  self.reset()
                  return True

              self.cfo_norm += f_int / float(self.L)
              cfo_hz = self.cfo_norm * self.fs
              # The grid we aligned on was early by f_int chips (CFO masqueraded as timing).
              # While searching for the SFD we stepped by the nominal L; the real symbol
              # length is L_eff (TX and RX each derive carrier AND chip clock from one
              # crystal -> relative clock error = -CFO/fc), so the payload start is
              # recomputed from the alignment instant with L_eff.
              if self.sro_comp:
                  self.L_eff = self.L * (1.0 - cfo_hz / self.fc)
              n_steps = int(round((self.pos - self.align_pos) / self.L))
              self.pos = self.align_pos + f_int * self.os + (n_steps + 2.25) * self.L_eff
              self.info.update({'cfo_int_bins': f_int, 'cfo_hz': float(cfo_hz),
                                'sync_bins': [int(b) for b in sync], 'drift_chips': d})
              self.state = 'OUTPUT'
              self.n_out, self.n_total = 0, None
              self.frames += 1
              if self.verbose:
                  print('[LoRa sync] frame %d: SNR %.1f dB, CFO %+.0f Hz (%d + %.2f bins), '
                        'sync word bins %s (drift %+.1f chips), sampling phase %d/%d'
                        % (self.frames, self.info['snr_db'], cfo_hz, f_int,
                           self.info['cfo_frac_bins'], list(sync), d, self.info['phase'], self.os),
                        flush=True)
              return True

          def step_output(self, out, nout):
              limit = 8 if self.n_total is None else self.n_total
              if self.n_out >= limit:
                  if self.n_total is not None:            # frame complete
                      if self.verbose and self.track and self.trk_hist:
                          print('[LoRa sync] frame %d: frequency tracked %+.0f Hz over the payload'
                                % (self.frames, (self.trk_hist[-1] - self.trk_hist[0]) * self.bw / self.N),
                                flush=True)
                      self.reset()
                      return nout, True
                  # waiting for the header decoder; give up after ~64 symbols of input
                  if self.buf_start + len(self.buf) - self.pos > 64 * self.L:
                      self.reset()
                      return nout, True
                  return nout, False
              if nout + self.N > len(out) or not self.have(self.pos, self.L + self.os):
                  return nout, False
              x = self.window(self.pos)
              if self.track:
                  # predict: apply the frequency expected for this symbol, then measure how far
                  # its de-chirped peak still sits from the bin centre and update the loop
                  x = x * np.exp(-2j * np.pi * self.trk_f * self.kk / self.N)
                  Y = np.fft.fft(x * self.down)
                  P = Y.real ** 2 + Y.imag ** 2
                  m = int(np.argmax(P))
                  if P[m] > self.trk_gate * np.mean(P):
                      a, b, c = Y[(m - 1) % self.N], Y[m], Y[(m + 1) % self.N]
                      den = 2 * b - a - c
                      delta = float(np.real((a - c) / den)) if abs(den) > 0 else 0.0
                      delta = float(np.clip(delta, -0.5, 0.5))   # residual offset [bins]
                      self.trk_r += self.trk_g2 * delta
                      self.trk_f += self.trk_g1 * delta
                  self.trk_hist.append(self.trk_f)
                  self.trk_f += self.trk_r
              out[nout:nout + self.N] = x.astype(np.complex64)
              if self.n_out == 0:
                  meta = pmt.make_dict()
                  for k, v in self.info.items():
                      meta = pmt.dict_add(meta, pmt.intern(k), pmt.to_pmt(v))
                  self.add_item_tag(0, self.nitems_written(0) + nout,
                                    pmt.intern('frame_start'), meta)
              self.n_out += 1
              self.pos += self.L_eff
              return nout + self.N, True

          # ------------------------------------------------------------ scheduler
          def forecast(self, noutput_items, ninputs):
              return [1] * ninputs

          def general_work(self, input_items, output_items):
              inp = input_items[0]
              n_in = len(inp)
              if n_in:
                  self.buf = np.concatenate((self.buf, inp))
                  self.consume(0, n_in)
              out = output_items[0]
              nout = 0
              while True:
                  if self.state == 'DETECT':
                      prog = self.step_detect()
                  elif self.state == 'SFD':
                      prog = self.step_sfd()
                  else:
                      nout, prog = self.step_output(out, nout)
                  if not prog:
                      break
              # keep 2 symbols of history behind the read pointer (alignment looks back)
              keep_from = int(self.pos) - 2 * self.L - self.os
              if keep_from > self.buf_start:
                  cut = keep_from - self.buf_start
                  self.buf = self.buf[cut:]
                  self.buf_start = keep_from
              return nout
    bw: bw
    center_freq: center_freq
    comment: |-
      EPB #1: preamble detect, CFO + timing, SFD, clock drift,
      cuts out aligned 1-sample/chip symbol windows
    preamble_len: preamble_len
    samp_rate: rx_rate
    sf: sf
    sro_comp: 'True'
    sync_word: sync_word
    track: 'True'
    verbose: 'True'
  states: {}
- name: mag2
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: N
  states: {}
- name: mag_sync
  id: blocks_complex_to_mag
  parameters:
    vlen: N
  states: {}
- name: mon_argmax
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: N
  states: {}
- name: mon_fft
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(N)
  states: {}
- name: mon_keep
  id: blocks_keep_one_in_n
  parameters:
    comment: 'MONITOR: 1 sample/chip, no alignment'
    n: rx_os
    type: complex
  states: {}
- name: mon_mag
  id: blocks_complex_to_mag
  parameters:
    vlen: N
  states: {}
- name: mon_mult
  id: blocks_multiply_xx
  parameters:
    comment: DE-CHIRP (free-running)
    type: complex
  states: {}
- name: mon_null
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: mon_ref
  id: blocks_vector_source_x
  parameters:
    comment: Endless down-chirps on an arbitrary time grid
    repeat: 'True'
    type: complex
    vector: downchirp
  states: {}
- name: mon_s2f
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: mon_s2v
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {}
- name: mon_time
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      Preamble = flat run at an ARBITRARY bin (timing + CFO);
      sync word = +8, +16 steps; payload = random bins; noise = random.
    entags: 'False'
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: '''peak bin'''
    marker1: '0'
    name: '"FREE-RUNNING de-chirp: argmax bin per 32.8 ms window"'
    size: '160'
    srate: 1.0/t_sym
    style1: '0'
    type: float
    ylabel: '"FFT bin"'
    ymax: N*1.05
    ymin: '-100'
  states: {}
- name: rtlsdr_source
  id: soapy_rtlsdr_source
  parameters:
    center_freq: center_freq - if_offset
    comment: |-
      LIVE: RTL-SDR via in-tree gr-soapy (radioconda ships SoapyRTLSDR).
      Tuned if_offset below 432.150 MHz.
    dev_args: '""'
    freq_correction: rtl_ppm
    gain: rtl_gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: sync_s2v
  id: blocks_stream_to_vector
  parameters:
    comment: Each N-sample block -> one vector
    num_items: N
    type: complex
  states: {}
- name: throttle
  id: blocks_throttle
  parameters:
    comment: Paces file playback (no hardware clock)
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: vec_sync
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 2,1,1,1
    label1: '''symbol'''
    name: '"SYNCHRONISED de-chirped spectrum of the latest symbol"'
    vlen: N
    x_axis_label: '"FFT bin = symbol value"'
    x_start: '0'
    x_step: '1'
    y_axis_label: '"|FFT|"'
    ymax: '1'
    ymin: '0'
  states: {}
- name: waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq - if_offset
    fftsize: '2048'
    gui_hint: 1,0,1,2
    int_max: '-40'
    int_min: '-110'
    name: '"RTL-SDR input: LoRa APRS burst at +" + str(int(if_offset/1e3)) + " kHz (" + str(center_freq/1e6) + " MHz)"'
    type: complex
    update_time: '0.05'
  states: {}
- name: xlating
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: if_offset
    comment: Shift +if_offset -> 0 Hz, low-pass, 1 MS/s -> 500 kS/s (4 samples/chip)
    decim: os_factor//rx_os
    samp_rate: samp_rate
    taps: rx_taps
    type: ccc
  states: {}

connections:
- [argmax, '0', lora_dec, '0']
- [argmax, '1', argmax_null, '0']
- [dechirp, '0', fft_sync, '0']
- [fft_sync, '0', mag2, '0']
- [fft_sync, '0', mag_sync, '0']
- [file_source, '0', throttle, '0']
- [lora_dec, frame_info, lora_sync, frame_info]
- [lora_dec, payload, aprs, pdu]
- [lora_sync, '0', sync_s2v, '0']
- [mag2, '0', argmax, '0']
- [mag_sync, '0', vec_sync, '0']
- [mon_argmax, '0', mon_s2f, '0']
- [mon_argmax, '1', mon_null, '0']
- [mon_fft, '0', mon_mag, '0']
- [mon_keep, '0', mon_mult, '0']
- [mon_mag, '0', mon_argmax, '0']
- [mon_mult, '0', mon_s2v, '0']
- [mon_ref, '0', mon_mult, '1']
- [mon_s2f, '0', mon_time, '0']
- [mon_s2v, '0', mon_fft, '0']
- [rtlsdr_source, '0', waterfall, '0']
- [rtlsdr_source, '0', xlating, '0']
- [sync_s2v, '0', dechirp, '0']
- [throttle, '0', waterfall, '0']
- [throttle, '0', xlating, '0']
- [xlating, '0', lora_sync, '0']
- [xlating, '0', mon_keep, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
